# Keil uVision project HailQuad.uvprojx, settings and files
target HailQuad (ARM-ADS)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H743xx
  c include: ..\CORE;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HALLIB\STM32H7xx_HAL_Driver\Inc;..\HARDWARE;..\FILTER;..\CONTROL;..\HARDWARE;..\HARDWARE\GPS;..\HARDWARE\SBUS;..\COMMAND\TAKEOFF;..\CONTROL\ATTITUDECONTROL;..\CONTROL\GROUNDCONTROL;..\CONTROL\HEIGHTCONTROL;..\CONTROL\POSITIONCONTROL;..\ELSE;..\FILTER\ATTITUDE;..\FILTER\HEIGHT;..\FILTER\POSITION;..\FILTER\VELOCITY;..\HARDWARE\GPS;..\HARDWARE\MPU9250;..\HARDWARE\SBUS;..\HARDWARE\SERVO;..\SYSTEM\delay;..\SYSTEM\dma;..\SYSTEM\iic;..\SYSTEM\sys;..\SYSTEM\timer;..\SYSTEM\uart;..\ELSE\GLOBAL;..\SYSTEM\spi;..\HARDWARE\HMC5983;..\CONTROL\POWERCONTROL
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group USER
    ./: main.c stm32h7xx_it.c system_stm32h7xx.c stm32h7xx_hal_msp.c
  group CORE
    ../CORE/: core_cm7.h cmsis_armcc.h cmsis_compiler.h startup_stm32h743xx.s
  group HALLIB
    ../HALLIB/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_usb.c stm32h7xx_ll_delayblock.c
  group HARDWARE
    ../HARDWARE/GPS/: gps.c gps.h
    ../HARDWARE/MPU9250/: MPU9250.c MPU9250.h
    ../HARDWARE/SERVO/: Servo.c Servo.h
    ../HARDWARE/SBUS/: SBUS.c SBUS.h
    ../HARDWARE/HMC5983/: hmc5983.c hmc5983.h
  group CONTROL
    ../CONTROL/ATTITUDECONTROL/: AttitudeControl.c AttitudeControl.h
    ../CONTROL/GROUNDCONTROL/: GroundControl.c GroundControl.h
    ../CONTROL/POSITIONCONTROL/: PositionColtrol.c PositionControl.h
    ../CONTROL/HEIGHTCONTROL/: HeightControl.c HeightControl.h
    ../CONTROL/POWERCONTROL/: PowerControl.c PowerControl.h
  group FILTER
    ../FILTER/ATTITUDE/: Attitude.c Attitude.h
    ../FILTER/HEIGHT/: Height.c Height.h
    ../FILTER/POSITION/: Position.c Position.h
    ../FILTER/VELOCITY/: Velocity.c Velocity.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c delay.h
    ../SYSTEM/dma/: dma.c dma.h
    ../SYSTEM/iic/: IIC.c IIC.h
    ../SYSTEM/sys/: sys.c sys.h
    ../SYSTEM/timer/: timer.c timer.h
    ../SYSTEM/uart/: usart.c usart.h
    ../SYSTEM/spi/: spi.c spi.h
  group COMMAND
    ../COMMAND/TAKEOFF/: TakeoffLand.c TakeOffLand.h
  group ELSE
    ../ELSE/GLOBAL/: global.c global.h
  group README
    ../README/: README.txt
